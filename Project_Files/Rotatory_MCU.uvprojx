# Keil uVision project Rotatory_MCU.uvprojx, settings and files
target Rotatory_MCU (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(100000000) ELITTLE
  output: Rotatory_MCU
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\Drivers\include;.\RTE\Device\LPC1768;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group User
    ../User/: main.c Messaging.c PID.c User_GPIO.c User_Uart.c User_ExtInt.c User_Delay.c Messaging_RSSI_SUM.c Messaging_RSSI_Delta.c lpc17xx_wdt.c Messaging_Freq.c
  group Drivers
    ../Drivers/source/: lpc17xx_clkpwr.c lpc17xx_exti.c lpc17xx_gpio.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_libcfg_default.c lpc17xx_systick.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
